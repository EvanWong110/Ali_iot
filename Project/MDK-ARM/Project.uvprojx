# Keil uVision project Project.uvprojx, settings and files
target Example (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __CC_ARM,__TARGET_FPU_VFP
  c include: ..\..\BSP\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Task\inc;..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\FreeRTOS\Source\include;..\..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Libraries\LwIP\src\include;..\..\Libraries\LwIP\port;..\..\Libraries\FatFs\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h lwipopts.h
  group BSP
    ../../BSP/src/: bsp_init.c bsp_lan8720.c bsp_uart.c netconf.c bsp_hash.c Ali_iot.c bsp_sdio.c bsp_sram.c bsp_rtc.c
  group Task
    ../../Task/src/: task_dhcp.c task_init.c
  group Libraries/CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_hash_sha1.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_sdio.c stm32f4xx_pwr.c
  group Libraries/STM32F4x7_ETH
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Libraries/FreeRTOS/Source
    ../../Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Libraries/MemMang
    ../../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Libraries/RVDS
    ../../Libraries/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Libraries/Lwip/src/core/ipv4
    ../../Libraries/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Libraries/Lwip/src/core
    ../../Libraries/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Libraries/Lwip/src/api
    ../../Libraries/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Libraries/Lwip/src/netif
    ../../Libraries/LwIP/src/netif/: ethernet.c
  group Libraries/Lwip/port
    ../../Libraries/LwIP/port/FreeRTOS/: ethernetif.c sys_arch.c
  group Libraries/Lwip/src/apps
    ../../Libraries/LwIP/src/apps/mqtt/: mqtt.c
  group Libraries/FatFs/source
    ../../Libraries/FatFs/source/: diskio.c ff.c ffsystem.c ffunicode.c
